# Keil uVision project GD32E103C_START.uvprojx, settings and files
target GD32E103C_CAP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32E103CB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin !L --output bin/GD32E103_app.bin
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,GD32E103C_START
  c include: ..\;..\GD32E10x_Firmware_Library\CMSIS\GD\GD32E10x\Include;..\GD32E10x_Firmware_Library\GD32E10x_standard_peripheral\Include;..\GD32E10x_Firmware_Library\CMSIS;..\Utilities;..\APP\inc;..\BSP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: systick.c gd32e10x_it.c
    ../APP/: algorithm.c Filter.c main.c MEMS.c modbus_asc.c task.c
  group BSP
    ../BSP/: AT24cxx.c Capacitive.c DA.c GD_FlashApp.c led.c MMA8652.c PCap.c SoftwareIIC.c usart.c ds18b20.c
  group CMSIS
    ../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group GD32E10x_Peripherals
    ../GD32E10x_Firmware_Library/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group Startup
    ../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Doc
    ../: readme.txt
software components: RTOS:kernel 3.1.3
